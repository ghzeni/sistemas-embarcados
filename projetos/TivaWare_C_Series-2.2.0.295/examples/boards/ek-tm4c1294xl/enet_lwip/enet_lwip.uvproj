# Keil uVision project enet_lwip.uvproj, settings and files
target enet_lwip (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: enet_lwip
  AfterMake: fromelf --bin --output .\rvmdk\enet_lwip.bin .\rvmdk\enet_lwip.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2 EK_TM4C129_BP1
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\lwip-1.4.1\apps;..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include;..\..\..\..\third_party\lwip-1.4.1\src\include;..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4;..\..\..\..\third_party
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: enet_lwip.sct
  link misc: --entry Reset_Handler
  group Source
    ./: enet_fs.c enet_lwip.c startup_rvmdk.S
    ../../../../third_party/fatfs/src/: ff.c
    ../../../../third_party/lwip-1.4.1/apps/httpserver_raw/: httpd.c
    ../../../../utils/: locator.c lwiplib.c uartstdio.c ustdlib.c
    ../../../../third_party/fatfs/port/: mmc-ek-tm4c1294xl.c
    ../drivers/: pinout.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
