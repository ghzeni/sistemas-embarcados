# Keil uVision project project0.uvprojx, settings and files
target project0 (6230000::V6.23::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project0
  AfterMake: fromelf --bin --output .\rvmdk\project0.bin .\rvmdk\project0.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA1
  c misc: -xc -std=c99
  c include: ..;..\..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: project0.sct
  link misc: --entry Reset_Handler
  group Source
    ./: project0.c startup_rvmdk.S
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 6.1.0
