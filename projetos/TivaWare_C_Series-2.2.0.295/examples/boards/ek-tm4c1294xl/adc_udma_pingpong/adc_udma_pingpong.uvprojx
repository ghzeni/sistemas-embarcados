# Keil uVision project adc_udma_pingpong.uvprojx, settings and files
target adc_udma_pingpong (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: adc_udma_pingpong
  AfterMake: fromelf --bin --output .\rvmdk\adc_udma_pingpong.bin .\rvmdk\adc_udma_pingpong.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2
  c misc: --c99
  c include: ..\..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: adc_udma_pingpong.sct
  link misc: --entry Reset_Handler
  group Source
    ./: adc_udma_pingpong.c startup_rvmdk.S
    ../../../../utils/: uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 6.1.0
